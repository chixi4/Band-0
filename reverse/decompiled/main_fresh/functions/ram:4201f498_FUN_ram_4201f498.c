
char * FUN_ram_4201f498(uint param_1)

{
  int iVar1;
  int iVar2;
  int iVar3;
  
  iVar2 = 0x50f;
  iVar1 = 0;
  do {
    iVar3 = (iVar1 + iVar2) / 2;
    if (*(ushort *)
         (
         "HwABAJ0f/wEAAU+AAAADGAABX//gAAAPGQACT/gAAB8ZAAJP/AAAPxkAAh/+GQAIL3/wRwEAbwf/AAB/wBkAAF8B/wAA/2UAAW/8f4AA/39+AAFff4AA/nxLAABfD7+AAP59AAJfv4AA/OAyAABfA5+AAPyWAAEPGQAGHwEyAAUPGQD//////////////zRpA4AA/MABoQsUGK4LQ/zAB/wMAGM4AAAHgDwNAK4A/MAP/hwAAABwGQAvH/8ZAAQoHg8ZAARKAPEGAPzAPAccA8AOcAB4OeAPB4AAB4B4HQDxlfzAPAB/j/H//gH+O/g/x4+8/8H9wAD+AAD8wB4Af5/5//4D/z/4f+ePPP/j/8ADAwAA/MAf4H++ef/+B88/fPnnnjz78+/ABgGAAPzAD/wcPDngcAeHPDzw57w88PeDwAcBgAD8wAf+HAA54HAHwDw8AOf4POD3g8AABwAA/MAA/xwP+eBwA/g4HD/n8Dzg94PAABwAAPzAAA+cP/ngcAP+OBz/MgBBgcAAGBkAEQcZAHIA/zgc/+f8SwAREMgA0geceDngcAAPuB3g57wZAAL6APMCDxx4eeBwB4e4HeHnnjzg98cZAPEGP/8efPngeAePOB3z55884PP/wAAw4QBx/x+/+eB+A2QAIY+8GQAheADhAPMBH5/54D4D/jgcf+eHvODx/TIAsgHwB48AAB4AeAAAvwETA2QAAWUBBwIAFAd9AAcUAAECADID/4CvAAEOAAcCAB8BGQAFIQD+JgAOMgAA5Q8BcQICCwAJAgAPxQ3/UQnmAwMCAAF3AQ8ZAAEvA5/SDwgj/vg/AAgCAC8fPzYQCB//5hABP/5/gJoQBw/MEAYfP5kQAQ8XEQoPfAABP////JQRCA/GEQYfAH0AAgEiAw8CAK1QAAAAAAA="
         + iVar3 * 4 + 0x2d4) == param_1) {
      return "8QYACAAAAAAAD/gAAAAAB//4AAAAAf8HABF/BwDxQz/////4AA//////4AP//////AD//////wA/+P///8AP/B////AH/gf///wB/4D/B/8Af+A/gf/AH/wf4D/gB/8P+A/4Af///wf+AP///8H/gD9LAKEP//w///gD//4HUQD2U4D//wA//+A//8Af//gf//AH//8H//wB///n//8Af/H///+AH/g////gB/wH///4A/8B/g/+AP/Af4H/gD/4P8B/4A//H/Af8AP///4H/AD///+D/wB//////8Af//////AHuwCB/gAf/////4AgABTg6ABRAH///gAHAAEQASF/wAcADwIAA1AAAAAAAA=="
             + (uint)*(ushort *)
                      (
                      "HwABAJ0f/wEAAU+AAAADGAABX//gAAAPGQACT/gAAB8ZAAJP/AAAPxkAAh/+GQAIL3/wRwEAbwf/AAB/wBkAAF8B/wAA/2UAAW/8f4AA/39+AAFff4AA/nxLAABfD7+AAP59AAJfv4AA/OAyAABfA5+AAPyWAAEPGQAGHwEyAAUPGQD//////////////zRpA4AA/MABoQsUGK4LQ/zAB/wMAGM4AAAHgDwNAK4A/MAP/hwAAABwGQAvH/8ZAAQoHg8ZAARKAPEGAPzAPAccA8AOcAB4OeAPB4AAB4B4HQDxlfzAPAB/j/H//gH+O/g/x4+8/8H9wAD+AAD8wB4Af5/5//4D/z/4f+ePPP/j/8ADAwAA/MAf4H++ef/+B88/fPnnnjz78+/ABgGAAPzAD/wcPDngcAeHPDzw57w88PeDwAcBgAD8wAf+HAA54HAHwDw8AOf4POD3g8AABwAA/MAA/xwP+eBwA/g4HD/n8Dzg94PAABwAAPzAAA+cP/ngcAP+OBz/MgBBgcAAGBkAEQcZAHIA/zgc/+f8SwAREMgA0geceDngcAAPuB3g57wZAAL6APMCDxx4eeBwB4e4HeHnnjzg98cZAPEGP/8efPngeAePOB3z55884PP/wAAw4QBx/x+/+eB+A2QAIY+8GQAheADhAPMBH5/54D4D/jgcf+eHvODx/TIAsgHwB48AAB4AeAAAvwETA2QAAWUBBwIAFAd9AAcUAAECADID/4CvAAEOAAcCAB8BGQAFIQD+JgAOMgAA5Q8BcQICCwAJAgAPxQ3/UQnmAwMCAAF3AQ8ZAAEvA5/SDwgj/vg/AAgCAC8fPzYQCB//5hABP/5/gJoQBw/MEAYfP5kQAQ8XEQoPfAABP////JQRCA/GEQYfAH0AAgEiAw8CAK1QAAAAAAA="
                      + iVar3 * 4 + 0x2d6) * 0x20 + 0xe0;
    }
    if (*(ushort *)
         (
         "HwABAJ0f/wEAAU+AAAADGAABX//gAAAPGQACT/gAAB8ZAAJP/AAAPxkAAh/+GQAIL3/wRwEAbwf/AAB/wBkAAF8B/wAA/2UAAW/8f4AA/39+AAFff4AA/nxLAABfD7+AAP59AAJfv4AA/OAyAABfA5+AAPyWAAEPGQAGHwEyAAUPGQD//////////////zRpA4AA/MABoQsUGK4LQ/zAB/wMAGM4AAAHgDwNAK4A/MAP/hwAAABwGQAvH/8ZAAQoHg8ZAARKAPEGAPzAPAccA8AOcAB4OeAPB4AAB4B4HQDxlfzAPAB/j/H//gH+O/g/x4+8/8H9wAD+AAD8wB4Af5/5//4D/z/4f+ePPP/j/8ADAwAA/MAf4H++ef/+B88/fPnnnjz78+/ABgGAAPzAD/wcPDngcAeHPDzw57w88PeDwAcBgAD8wAf+HAA54HAHwDw8AOf4POD3g8AABwAA/MAA/xwP+eBwA/g4HD/n8Dzg94PAABwAAPzAAA+cP/ngcAP+OBz/MgBBgcAAGBkAEQcZAHIA/zgc/+f8SwAREMgA0geceDngcAAPuB3g57wZAAL6APMCDxx4eeBwB4e4HeHnnjzg98cZAPEGP/8efPngeAePOB3z55884PP/wAAw4QBx/x+/+eB+A2QAIY+8GQAheADhAPMBH5/54D4D/jgcf+eHvODx/TIAsgHwB48AAB4AeAAAvwETA2QAAWUBBwIAFAd9AAcUAAECADID/4CvAAEOAAcCAB8BGQAFIQD+JgAOMgAA5Q8BcQICCwAJAgAPxQ3/UQnmAwMCAAF3AQ8ZAAEvA5/SDwgj/vg/AAgCAC8fPzYQCB//5hABP/5/gJoQBw/MEAYfP5kQAQ8XEQoPfAABP////JQRCA/GEQYfAH0AAgEiAw8CAK1QAAAAAAA="
         + iVar3 * 4 + 0x2d4) < param_1) {
      iVar1 = iVar3 + 1;
    }
    else {
      iVar2 = iVar3 + -1;
    }
  } while (iVar1 <= iVar2);
  return (char *)0x0;
}

