
/* WARNING: Globals starting with '_' overlap smaller symbols at the same address */

void FUN_ram_4201a690(void)

{
  int iVar1;
  
  iVar1 = FUN_ram_4201f03c();
  if (iVar1 == 0) {
    if (_DAT_ram_3fcc5080 != 1) {
      if (_DAT_ram_3fcc5080 != 2) {
        if (_DAT_ram_3fcc5080 == 0) {
          FUN_ram_4201a554();
          if (*(char *)(gp + -0x792) == '\0') goto LAB_ram_4201a740;
          FUN_ram_4201ef22();
          *(undefined1 *)(gp + -0x792) = 0;
        }
        return;
      }
      FUN_ram_4201a586("EQABADEP//AIAAICAFIB////gAsAAB8AUh/////4CwAALgBS//gAH/8LAKEAAAAH/gAAAH/gDACVAAAAH+AAAAAHLgBxfwAH/+AA/hsAQQAAAfwPABM/XAASB3QAEw89ACEPwCcAEgMWADEAPwAtACFA/BYAoQB8DwD///8A8D4PAKEB+D4P+AAf8HwfTAChA+B4PwAAAPweB0QAoQfB4fgAAAAfh4NbAKEPB4fAAAAAA+HgWwCwHg8fAA///gD48Hj9ALA8HDwAD///ADw4PAwBMXgI8A8AMA8QHhsBMfABwA8AoQOADwAAAAHgB4APAAEJAFEAA8AOAA8A8wkAcAPAAAAHgBwAAA+APwAAOAHgAAAPADgPAOIcAPAAAA4AcAAA/4A/wAoA8W0eAOAAB/+AP/gABwB4AAA8AcAAP/+AP/4AA4A8AAA4Q4AA//+AP/+AAcAcAAB45wAB//gAD//gAOceAADxzgAH/4AAAH/wAHOPAADhjAAP/AAAAB/4ADGHAAHjmAAf8AAAAAP+ABnHgAHDOAA/wAAAAAH/ABzjgAPGMAB/NAGDf4AMY8ADjmCeAZI/wAZxwAeM4ABwAZIfwAcx4AccwAHLAfN/D+ADOOAPGcAB+AAPgBAAB/ADmPAOOYAD8AA/gD4AA/gBnHAOE4AD4AD/gD8AA/gByHAcAwAD4AH/gD/AB/AAwDgcAwAH4AP/gD/wD+AA4DgcBgAHwAf/gD/4H8AAYDg4BgAHwAfvgD/8P4AAYBw4DgAHwA/PgD/+fwAAcBw4DAAHwA/PgD///gAAMBw4DB4Agz/8AAAwHHAMSwCDH/wAADAOcBgPAFIP+AAAGA8AZAP/gD8P8A8AAZYAIwfgDwACtABxA8AAABgO8A8A8gk/gD/hgAAAGA/jMAAD8AAHgD/8AAAADMcPAFMAAD//gA8AAR0BMx//4A8AATsBNAP/+A8AEP5cAyQ//A8AFH8vAwFLAAKVATIA/4BaAAKzATMAf8APABEPPQAUHw8AMgf/wCoDAjwAMgH/+EADAg8AMgh//DkDAg8Agwwf/AHAAAH4SwBSHgf8AfwPAPIM8BgAAD8A/AH/gAD4ABgPcBgAAH+A/AH/4AD4LAF1AH/A/AH/8A8Agv/g/AH/+AD8HgByAf/w/AH3/A8A8wsMAAP7+PwB8PwA/AAwDjgMAAfx/PwB8HwA/KQBIeD/DwCh+AAwHDgOAA/Afy0A8Qr4AHAcOAYAH8A//AHz+AD4AGAcHAYAP4AfaQDyAfgAYDgcBwB/AA/8Af/wAfg6AvECfgAD/AH/4AHwAMA4DhOAfgDDAPEXA/AByHAOOYB/AAA8Af4AA/ABnHAPGcA/gAAAAfAAB+ADmPAHHMCRBAPBAkEHjOAPAwSiAB/ABzHgA45gB98CkT+ABnHAA8YwA3YBoQB/AAxhwAHHOAHnBAI5AzIB45jnBAJXA2UA4YwAP/h1A6IA8c4AH/+AAAD/kwNBeOcABygFQeAA5w7PA6IB//wB//+AAcIe7QNDf/wB/+0DMR4A4PAAAwsEUQ4AcAABpAEBMwQBRwQz/AH4RwQBZQQz/AHwZQQBgwQBDwABgwQBmAQy///wqgQCvwR0///wAAOAD90ENP//8N0EdDwcPAD///D7BDEeDx8PAAMZBQs3BQtVBZID4Pg/AAAA/h9zBSMB8JEFIQ+AoQUKrwU5AD8CzQUCtgUiAAGNAQQJBhEHrgUNJwYLRQYMYwYLgQYRAHcBAYQAAQIAC70GC9sGoAAP//AAAAAAAAA="
                       + _DAT_ram_3fcc5070 * 8 + 0x5e0);
LAB_ram_4201a740:
      FUN_ram_4201f108(0,199);
      return;
    }
    FUN_ram_4201a586("EQABADEP//AIAAICAFIB////gAsAAB8AUh/////4CwAALgBS//gAH/8LAKEAAAAH/gAAAH/gDACVAAAAH+AAAAAHLgBxfwAH/+AA/hsAQQAAAfwPABM/XAASB3QAEw89ACEPwCcAEgMWADEAPwAtACFA/BYAoQB8DwD///8A8D4PAKEB+D4P+AAf8HwfTAChA+B4PwAAAPweB0QAoQfB4fgAAAAfh4NbAKEPB4fAAAAAA+HgWwCwHg8fAA///gD48Hj9ALA8HDwAD///ADw4PAwBMXgI8A8AMA8QHhsBMfABwA8AoQOADwAAAAHgB4APAAEJAFEAA8AOAA8A8wkAcAPAAAAHgBwAAA+APwAAOAHgAAAPADgPAOIcAPAAAA4AcAAA/4A/wAoA8W0eAOAAB/+AP/gABwB4AAA8AcAAP/+AP/4AA4A8AAA4Q4AA//+AP/+AAcAcAAB45wAB//gAD//gAOceAADxzgAH/4AAAH/wAHOPAADhjAAP/AAAAB/4ADGHAAHjmAAf8AAAAAP+ABnHgAHDOAA/wAAAAAH/ABzjgAPGMAB/NAGDf4AMY8ADjmCeAZI/wAZxwAeM4ABwAZIfwAcx4AccwAHLAfN/D+ADOOAPGcAB+AAPgBAAB/ADmPAOOYAD8AA/gD4AA/gBnHAOE4AD4AD/gD8AA/gByHAcAwAD4AH/gD/AB/AAwDgcAwAH4AP/gD/wD+AA4DgcBgAHwAf/gD/4H8AAYDg4BgAHwAfvgD/8P4AAYBw4DgAHwA/PgD/+fwAAcBw4DAAHwA/PgD///gAAMBw4DB4Agz/8AAAwHHAMSwCDH/wAADAOcBgPAFIP+AAAGA8AZAP/gD8P8A8AAZYAIwfgDwACtABxA8AAABgO8A8A8gk/gD/hgAAAGA/jMAAD8AAHgD/8AAAADMcPAFMAAD//gA8AAR0BMx//4A8AATsBNAP/+A8AEP5cAyQ//A8AFH8vAwFLAAKVATIA/4BaAAKzATMAf8APABEPPQAUHw8AMgf/wCoDAjwAMgH/+EADAg8AMgh//DkDAg8Agwwf/AHAAAH4SwBSHgf8AfwPAPIM8BgAAD8A/AH/gAD4ABgPcBgAAH+A/AH/4AD4LAF1AH/A/AH/8A8Agv/g/AH/+AD8HgByAf/w/AH3/A8A8wsMAAP7+PwB8PwA/AAwDjgMAAfx/PwB8HwA/KQBIeD/DwCh+AAwHDgOAA/Afy0A8Qr4AHAcOAYAH8A//AHz+AD4AGAcHAYAP4AfaQDyAfgAYDgcBwB/AA/8Af/wAfg6AvECfgAD/AH/4AHwAMA4DhOAfgDDAPEXA/AByHAOOYB/AAA8Af4AA/ABnHAPGcA/gAAAAfAAB+ADmPAHHMCRBAPBAkEHjOAPAwSiAB/ABzHgA45gB98CkT+ABnHAA8YwA3YBoQB/AAxhwAHHOAHnBAI5AzIB45jnBAJXA2UA4YwAP/h1A6IA8c4AH/+AAAD/kwNBeOcABygFQeAA5w7PA6IB//wB//+AAcIe7QNDf/wB/+0DMR4A4PAAAwsEUQ4AcAABpAEBMwQBRwQz/AH4RwQBZQQz/AHwZQQBgwQBDwABgwQBmAQy///wqgQCvwR0///wAAOAD90ENP//8N0EdDwcPAD///D7BDEeDx8PAAMZBQs3BQtVBZID4Pg/AAAA/h9zBSMB8JEFIQ+AoQUKrwU5AD8CzQUCtgUiAAGNAQQJBhEHrgUNJwYLRQYMYwYLgQYRAHcBAYQAAQIAC70GC9sGoAAP//AAAAAAAAA="
                     + *(int *)(&DAT_ram_3fcc5074 + _DAT_ram_3fcc507c * 4) * 8 + 0x630);
    FUN_ram_4201f108(0,199);
    _DAT_ram_3fcc507c = _DAT_ram_3fcc507c + 1;
    if (1 < _DAT_ram_3fcc507c) {
      _DAT_ram_3fcc5080 = 2;
    }
  }
  FUN_ram_42018dcc();
  return;
}

