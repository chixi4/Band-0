
void FUN_ram_420226aa(undefined4 param_1)

{
  uint uVar1;
  int iVar2;
  uint uVar3;
  
  FUN_ram_420b52ca();
  FUN_ram_420b52da();
  FUN_ram_4206614c(param_1,"ng resources today.");
  FUN_ram_42066162(param_1,&DAT_ram_3c0c1a2c);
  FUN_ram_42066116(param_1,&DAT_ram_3c0c195c,"ep.");
  FUN_ram_42066116(param_1,"l before sleep.","ture goal before sleep.");
  uVar1 = 0;
  while( true ) {
    uVar3 = 0x247f - uVar1;
    if (0x400 < uVar3) {
      uVar3 = 0x400;
    }
    iVar2 = FUN_ram_4206632e(param_1,"HwABAJ0vf/8BAABPAAAAARcAAG///8AAAAcZAAJP8AAADxkAAk/4AAAfGQACT/wAAD8ZAAJf/gAAP8BHAQBvAf4AAH+AGQAAXwD/AAB/fgABX/h/AAD+ZQABb/4/gAD8cEsAAG8HH4AA/GAZAABfAx+AAPyWAAIfnxkA//////+8DPkFBNwFIgP8HAAQMN4HJj/wGQAoB44ZABbgGQAiDgcZAAECACYwABkANhwDgGcACBkA2hgBjPBmAgIDMDwwIEAZAMfP+GYGBwMw/jBwwDFLANg4AM8cZgYDBjHHGHDAfQDnMADODGMGAwYxgxjwwDivAPYAMADMDGMMAYYzAZjRgHAwlgD2ADAAzAxhDAGMM/+YmYAAOBkA9gA4AcwMYYgBjDP/jZmAABgZANgYAYwMYZgAzDMADYkAGQCBHAGMDGCYANgZABdgMgDYDAMMDGDQAFgxgYcPAH0A9gAPDwwMYPAAcDHDBw8AOHBkAOcD/gwMYHAAcDD+BwYAH+EA9gAA8AQEQGAAIDA4AgYAB4AyAAECAAVfAQcsAQECAAi/BwTbAV8AAAAAAxkABgIgAAICAAgyAAkCAA8ZACYIdwACXAIDSwAYw2AACBkAHwMZAB70Ak/B4E4eA8AI4A8GYA8weCAQsQj0As/H8P8/D+Af+D+H4D+w/jAwGQD3AMMOGOHjnDAOHHHHADDxhxkA9QEMHOHBmDAMDGDGAGBxAxhgMgDYDAzAwZwADAzAZgBgcBkA5x/8wIGPAAwO/+YAYDAfMgD1AR/8wIGH4AgG/+YAYDH/DMBLAOcYAMCBgPAMDsAGAGAzgxkA6AwAwIGAMAwMwAYAYHMDGQAxDMCBlgB1ZgBgcwcHgEsA9QEOGMCBnDAOHHDGADDzjweGGQD0Acf4wcGP4Av4P4YAP7H7Aw4ZAPQCQcHgQIEDwAjgDgYADiDzAwQZAAN2ARMICAAVA6kBAxEABBkAHAYZABMcIQAcHhkABDIAByADDQIAAw0CDRgAC5YABwIADzIA//////8LCBMIBAIAAdIPDwQQBQ82EAYPaBAGD5oQBg/MEAYPmRABAf4QDzARBg/kEAEBYhEPlBEGD8YRBg/4EQYPAgCvUAAAAAAA"
                                     + uVar1 + 0x244,uVar3);
    if (iVar2 != 0) break;
    uVar1 = uVar1 + uVar3;
    if (0x247e < uVar1) {
      FUN_ram_4206632e(param_1,0,0);
      return;
    }
  }
  return;
}

